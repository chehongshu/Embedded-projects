# Keil uVision project Mechanical_design.uvprojx, settings and files
target Mechanical_design (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Mechanical_design +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\EXTI;..\HARDWARE\Hall_element;..\HARDWARE\LED;..\HARDWARE\Photoelectric_door;..\HARDWARE\KEY;..\HARDWARE\Stepper_Motor;..\HARDWARE\TIMER;..\HARDWARE\function;..\HARDWARE\sortsOf_ways;..\HARDWARE\Hair_dryer;..\HARDWARE\details_func
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Photoelectric_door/: Photoelectric_door.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Stepper_Motor/: steppermotor.c
    ../HARDWARE/function/: function.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/sortsOf_ways/: sortsOf_ways.c
    ../HARDWARE/Hair_dryer/: Hair_dryer.c
    ../HARDWARE/details_func/: details_func.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group README
    ../: README.TXT
